FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI:append = "file://0001-Fix-Eigen-branch-hash-issue.patch"

